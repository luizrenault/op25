<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>click_freq</value></param>
<param><key>value</key><value>freq-config_xlate_offset</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_channel_rate</value></param>
<param><key>value</key><value>samp_rate/decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>5+1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fine_click_freq</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>auto_tune_offset</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_rate</value></param>
<param><key>value</key><value>oop25.SYMBOL_RATE*samp_per_sym</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_offset_fine</value></param>
<param><key>label</key><value>Fine Offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-10000</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_bandwidth</value></param>
<param><key>label</key><value>Xlate BW</value></param>
<param><key>value</key><value>config_xlate_bandwidth</value></param>
<param><key>min</key><value>5000</value></param>
<param><key>max</key><value>50000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_xlate_bandwidth</value></param>
<param><key>value</key><value>24000</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.grc_op25</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>xlate_bandwidth</value></param>
<param><key>writeback</key><value>xlate_bandwidth</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>xlate_offset</value></param>
<param><key>label</key><value>Xlate Offset</value></param>
<param><key>value</key><value>freq-click_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>config_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_xlate_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.grc_op25</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>xlate_offset</value></param>
<param><key>writeback</key><value>xlate_offset+xlate_offset_fine</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_freq</value></param>
<param><key>value</key><value>861.54e6</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.grc_op25</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>writeback</key><value>freq</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from baz import op25 as oop25</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>auto_tune_offset_freq</value></param>
<param><key>label</key><value>Auto tune</value></param>
<param><key>value</key><value>auto_tune_offset*oop25.SYMBOL_DEVIATION</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>gr_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>(channel_rate/(2.0 * math.pi * oop25.SYMBOL_DEVIATION))</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/luizrenault/aaa.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>0</value></param>
<param><key>gain0</key><value>-20</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>gr_freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, xlate_bandwidth/2, 1000)</value></param>
<param><key>center_freq</key><value>xlate_offset+xlate_offset_fine-fine_click_freq-auto_tune_offset_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_1</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>channel_rate</value></param>
<param><key>decim</key><value>pre_channel_rate</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>v_scale</key><value>1</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>.001</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>op25_decoder_bf</key>
<param><key>id</key><value>op25_decoder_bf_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>op25_fsk4_slicer_fb</key>
<param><key>id</key><value>op25_fsk4_slicer_fb_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>slice_levels</key><value>-2, 0, 2, 4 </value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>gr_fir_filter_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>(1.0/samp_per_sym,)*samp_per_sym</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>v_scale</key><value>1</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>.001</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>op25_decoder</key>
<param><key>id</key><value>op25_decoder_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>channel_rate</key><value>channel_rate</value></param>
<param><key>key</key><value></value></param>
<param><key>dibits_out</key><value>True</value></param>
<param><key>tune_out</key><value>False</value></param>
</block>
<block>
<key>op25_fsk4_demod_ff</key>
<param><key>id</key><value>op25_fsk4_demod_ff_0</value></param>
<param><key>queue</key><value>gr.msg_queue(2)</value></param>
<param><key>sample_rate</key><value>channel_rate</value></param>
<param><key>symbol_rate</key><value>channel_rate/samp_per_sym</value></param>
</block>
<connection><source_block_id>gr_quadrature_demod_cf_0</source_block_id><sink_block_id>gr_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>gr_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>gr_freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fir_filter_xxx_0</source_block_id><sink_block_id>op25_fsk4_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_fsk4_slicer_fb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fir_filter_xxx_0</source_block_id><sink_block_id>op25_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_fsk4_slicer_fb_0</source_block_id><sink_block_id>op25_decoder_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_decoder_bf_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_decoder_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_decoder_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fir_filter_xxx_0</source_block_id><sink_block_id>op25_fsk4_demod_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_fsk4_demod_ff_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
